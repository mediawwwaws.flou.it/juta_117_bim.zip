Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 51b8acce-b227-433e-ad70-f47440eab0b4, VersionGUID: e93f5e7b-1c01-4e72-b6e4-7e64eeaf7629, NumberOfSaves: 3], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Planimetria di default], ExchangeRequirement [Architecture]
File name: Juta_117-Juta_117.ifc
Time: 2025-10-21T14:57:44+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (ITA) - IFC 25.4.0.27

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Pset_SiteCommon - Reference: Informazioni sul progetto
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - Reference: Informazioni sul progetto; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Informazioni sul progetto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informazioni sul progetto; sets with these values: 2
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello (2)
Pset_BuildingStoreyCommon - Reference: Livello
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Quote - Altezza di calcolo: 0 m
Dati identità - Piano edificio: yes; Strutturale: no
Altro(Tipo) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Tipo) - Base quota altimetrica: Punto base progetto
Grafica(Tipo) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Tipo) - Nome del tipo: Livello
Name | LongName = Nome | Elevation (m) = Quota altimetrica (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurniture: Juta_117:Juta_117, Juta_117:Juta_117:142126
In: 0 - Piano Terra
Type - Material: <Unnamed>
Type - Altro - Categoria: Arredi; Nome famiglia: Juta_117
Type - Vincoli - Prospetto di default: 0 m
Type - Quote - Altezza: 0 m
Type - Dati identità - Designer: Pinuccio Borgonuovo; Nome del tipo: Juta_117
Type - INFORMAZIONI - DESIGNER: Pinuccio Borgonuovo
Pset_EnvironmentalImpactIndicators - Reference: Juta_117; sets with these values: 2
Altro - Famiglia: Juta_117; Famiglia e tipo: Juta_117: Juta_117; ID tipo: 140428; Tipo: Juta_117
Vincoli - Host: Muro di base : Generico - 30 cm; Livello: 0 - Piano Terra; Offset da host: 0 m; Quota altimetrica da livello: 0 m; Sposta con gli elementi più vicini: no
Fasi - Fase di creazione: Stato di Progetto
